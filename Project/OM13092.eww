<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OM13092.ewp</path>
    </project>
    <batchBuild />
</workspace>
