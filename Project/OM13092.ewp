# IAR project OM13092.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512 NXP LPC54608J512
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_LPC54608; CPU_LPC54608J512ET180=1; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\Components\FreeRTOS\portable\IAR\ARM_CM4F; ..\Components\FreeRTOS\include; ..\Board\Include; ..\Drivers\Include; ..\Device\Include; ..\App\Include; ..\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\App\Include
  OBJCOPY.OOCOutputFile: OM13092.srec
  ILINK.IlinkOutputFile: OM13092.out
  ILINK.IlinkIcfFile: LPC54608J512_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/Source/: main.c
  group Board
    ../Board/Source/: board.c clock_config.c pin_mux.c
  group Components/FreeRTOS
    ../Components/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Components/FreeRTOS/portable
    ../Components/FreeRTOS/portable/MemMang/: heap_4.c
    ../Components/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Device
    ../Device/Source/: iar_lib_power.a startup_LPC54608.s system_LPC54608.c
  group Drivers
    ../Drivers/Source/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_eeprom.c fsl_emc.c fsl_enet.c fsl_flashiap.c fsl_flexcomm.c fsl_fmc.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2c_freertos.c fsl_i2s.c fsl_i2s_dma.c fsl_iap.c fsl_inputmux.c fsl_lcdc.c fsl_mcan.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rit.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_spi_freertos.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c fsl_usart_dma.c fsl_usart_freertos.c fsl_utick.c fsl_wwdt.c
